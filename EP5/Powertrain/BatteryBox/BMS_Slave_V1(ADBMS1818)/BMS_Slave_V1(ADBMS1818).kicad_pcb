# Repository NTURacingTeam/nturt_kicad

## KiCad design EP5/Powertrain/BatteryBox/BMS_Slave_V1(ADBMS1818)/BMS_Slave_V1(ADBMS1818).kicad_pcb

Parts:
C101, C102, C103, C104, C105, C106, C107, C108, C109, C110, C111, C112, C113, C114, C115, C118, C119, C120, C121, C122, C123, C124, C125, C126, C127, C128, C129, C130, C131, C132, C137, C138, C141, C142, C143, C144, C145, C146, C147, C148, C149, C150, C151, C152, C153, C154, C155, C156, C157, C158, C159, C160, C161, C162, C163, C164, C165, C166, C167, C168, C169, C170, C171, C172, C173, C174: 10n; C_0603_1608Metric
C116, C117, C133, C134, C135, C136: 100n; C_0603_1608Metric
C139, C140: 100p; C_0603_1608Metric
C175, C176, C177, C178: 1uF; C_0805_2012Metric
C179, C180: 10nF; C_0603_1608Metric
D101, D102, D103, D104, D105, D106, D107, D108, D109, D110, D111, D112, D113, D114, D115, D116: RED; LED_0603_1608Metric
F101, F102, F103, F104, F105, F106, F107, F108, F109, F110, F111, F112, F113, F114, F115, F116: 0466.250NR; Fuse_1206_3216Metric; Mouser Part Number 576-0466.250NR
H101, H102, H103, H104: MountingHole; MountingHole_4.3mm_M4_DIN965
IC101, IC102, IC103, IC104, IC105, IC106, IC107, IC108, IC109, IC110, IC111, IC112, IC113, IC114, IC115: NX2301P,215; SOT-23; Mouser Part Number 771-NX2301P215
IC116, IC117, IC118, IC119: ADG728BRUZ; SOP65P640X120-16N; Mouser Part Number 584-ADG728BRUZ
IC120: ADBMS1818ASWAZ-R7; LQFP-64-1EP_10x10mm_P0.5mm_EP6.5x6.5mm; Mouser Part Number 584-ADBMS1818ASWAZR7
IC121, IC122: AD8628ARTZ-R2; SOT95P280X145-5N; Mouser Part Number 584-AD8628ARTZ-R2
J101, J102: RJ45; RJ45_Amphenol_54602-x08_Horizontal
J103: Conn_01x16; JST_XH_B16B-XH-A_1x16_P2.50mm_Vertical
J104, J105, J106, J107: Conn_01x16; JST_PH_B16B-PH-K_1x16_P2.00mm_Vertical
R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115: 510; R_0603_1608Metric
R116, R117, R118, R119, R120, R121, R122, R123, R124, R125, R126, R127, R128, R129, R130, R131, R132, R133, R134, R135, R136, R137, R138, R139, R140, R141, R142, R143, R144, R145: 130; R_2512_6332Metric
R146, R147, R148, R149, R150, R151, R152, R153, R154, R155, R156, R157, R158, R159, R160: 3.3k; R_0603_1608Metric
R161, R162, R163, R164, R165, R166, R167, R168, R169, R170, R171, R172, R173, R174, R175, R176, R177, R178, R179, R180, R181, R219, R220, R221, R222, R223, R224, R225, R226, R227, R228, R229, R230, R231, R232, R233, R234, R235, R236, R237, R238, R239, R240, R241, R242, R243, R244, R245, R246, R247, R248, R249, R250, R254: 100; R_0603_1608Metric
R182, R252, R253: 1k; R_0603_1608Metric
R183, R184, R185, R186, R187, R188, R189, R190, R191, R192, R193, R194, R195, R196, R197, R198, R199, R200, R201, R202, R203, R204, R205, R206, R207, R208, R209, R210, R211, R212, R213, R214, R217, R218: 10k; R_0603_1608Metric
R215, R216: 120R; R_0603_1608Metric
R251: 1M; R_0603_1608Metric
TR101: Wuerth_749013011A; Transformer_Ethernet_Wuerth_749013011A
Z101, Z102, Z103, Z104, Z105, Z106, Z107, Z108, Z109, Z110, Z111, Z112, Z113, Z114, Z115: MMSZ4692T1G; D_SOD-123; Mouser Part Number 863-MMSZ4692T1G

Connections:
/Power/VIN: C116.1, R161.2; also elsewhere on the board
AMP_IN+: IC116.8 (D), IC117.8 (D), IC118.8 (D), IC119.8 (D), IC122.3 (+IN)
C0: C132.2, IC120.38 (C0), R181.2, Z115.2 (A)
C1: C115.1, C131.2, C132.1, IC120.36 (C1), R180.2, Z114.2 (A), Z115.1 (K)
C2: C114.1, C130.2, C131.1, IC120.34 (C2), R179.2, Z113.2 (A), Z114.1 (K)
C3: C113.1, C129.2, C130.1, IC120.32 (C3), R178.2, Z112.2 (A), Z113.1 (K)
C4: C112.1, C128.2, C129.1, IC120.30 (C4), R177.2, Z111.2 (A), Z112.1 (K)
C5: C111.1, C127.2, C128.1, IC120.28 (C5), R176.2, Z110.2 (A), Z111.1 (K)
C6: IC120.26 (C6), R175.2
C7: C110.1, C126.2, C127.1, IC120.24 (C7), R174.2, Z109.2 (A), Z110.1 (K)
C8: C109.1, C125.2, C126.1, IC120.22 (C8), R173.2, Z108.2 (A), Z109.1 (K)
C9: C108.1, C124.2, C125.1, IC120.20 (C9), R172.2, Z107.2 (A), Z108.1 (K)
C10: C107.1, C123.2, C124.1, IC120.18 (C10), R171.2, Z106.2 (A), Z107.1 (K)
C11: C106.1, C122.2, C123.1, IC120.16 (C11), R170.2, Z105.2 (A), Z106.1 (K)
C12: IC120.14 (C12), R169.2
C13: C105.1, C121.2, C122.1, IC120.12 (C13), R168.2, Z104.2 (A), Z105.1 (K)
C14: C104.1, C120.2, C121.1, IC120.10 (C14), R167.2, Z103.2 (A), Z104.1 (K)
C15: C103.1, C119.2, C120.1, IC120.8 (C15), R166.2, Z102.2 (A), Z103.1 (K)
C16: C102.1, C118.2, C119.1, IC120.6 (C16), R165.2, Z101.2 (A), Z102.1 (K)
C17: C101.1, C118.1, IC120.4 (C17), R164.2, Z101.1 (K)
C18: IC120.2 (C18), R163.2
Cell0+: F115.2, IC115.2 (S), R114.2, R129.1, R144.1, R180.1
Cell0-: C101.2, C102.2, C103.2, C104.2, C105.2, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, C113.2, C114.2, C115.2, C116.2, C117.2, C133.2, C134.2, C135.2, C136.2, C137.1, C138.1, C139.2, C140.1, C141.2, C142.2, C143.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.1, C174.1, C175.1, C176.1, C177.1, C178.2, C179.1, C180.2, F116.2, IC116.14 (GND), IC116.15 (A1), IC116.16 (A0), IC117.14 (GND), IC117.15 (A1), IC118.14 (GND), IC118.16 (A0), IC119.14 (GND), IC120.59 (V-_1), IC120.60 (V-_2), IC120.65 (V-_3), IC121.2 (V-), IC122.2 (V-), J104.2, J104.4, J104.6, J104.8, J104.10, J104.12, J104.14, J104.16, J105.2, J105.4, J105.6, J105.8, J105.10, J105.12, J105.14, J105.16, J106.2, J106.4, J106.6, J106.8, J106.10, J106.12, J106.14, J106.16, J107.2, J107.4, J107.6, J107.8, J107.10, J107.12, J107.14, J107.16, R115.2, R130.1, R145.1, R181.1, R182.2, R253.1; also elsewhere on the board
Cell1+: F114.2, IC114.2 (S), R113.2, R128.1, R143.1, R179.1
Cell2+: F113.2, IC113.2 (S), R112.2, R127.1, R142.1, R178.1
Cell3+: F112.2, IC112.2 (S), R111.2, R126.1, R141.1, R177.1
Cell4+: F111.2, IC111.2 (S), R101.2, R125.1, R140.1, R175.1, R176.1
Cell5+: F110.2, IC110.2 (S), R110.2, R124.1, R139.1, R174.1
Cell6+: F109.2, IC109.2 (S), R109.2, R123.1, R138.1, R173.1
Cell7+: F108.2, IC108.2 (S), R108.2, R122.1, R137.1, R172.1
Cell8+: F107.2, IC107.2 (S), R107.2, R121.1, R136.1, R171.1
Cell9+: F106.2, IC106.2 (S), R106.2, R120.1, R135.1, R169.1, R170.1
Cell10+: F105.2, IC105.2 (S), R105.2, R119.1, R134.1, R168.1
Cell11+: F104.2, IC104.2 (S), R104.2, R118.1, R133.1, R167.1
Cell12+: F103.2, IC103.2 (S), R103.2, R117.1, R132.1, R166.1
Cell13+: F102.2, IC102.2 (S), R102.2, R116.1, R131.1, R165.1
Cell14+: F101.2, IC101.2 (S), R161.1, R162.1, R163.1, R164.1
DRIVE: IC120.49 (DRIVE); also elsewhere on the board
GPIO1: C180.1, IC120.39 (GPIO1), R254.2
GPIO4: IC116.3 (SDA), IC117.3 (SDA), IC118.3 (SDA), IC119.3 (SDA), IC120.42 (GPIO4), R218.2
GPIO5: IC116.1 (SCL), IC117.1 (SCL), IC118.1 (SCL), IC119.1 (SCL), IC120.43 (GPIO5), R217.1
IBIAS: IC120.57 (IBIAS), R252.2
ICMP: IC120.58 (ICMP), R252.1, R253.2
IN_N1: IC120.61 (CSB), R216.2, TR101.16 (TX+)
IN_P1: IC120.62 (SCK), R216.1, TR101.14 (TX-)
unnamed: D101.2 (A), IC110.3 (D), R125.2, R140.2
unnamed: D101.1 (K), R101.1
unnamed: D102.2 (A), IC101.3 (D), R116.2, R131.2
unnamed: D102.1 (K), R102.1
unnamed: D103.2 (A), IC102.3 (D), R117.2, R132.2
unnamed: D103.1 (K), R103.1
unnamed: D104.2 (A), IC103.3 (D), R118.2, R133.2
unnamed: D104.1 (K), R104.1
unnamed: D105.2 (A), IC104.3 (D), R119.2, R134.2
unnamed: D105.1 (K), R105.1
unnamed: D106.2 (A), IC105.3 (D), R120.2, R135.2
unnamed: D106.1 (K), R106.1
unnamed: D107.2 (A), IC106.3 (D), R121.2, R136.2
unnamed: D107.1 (K), R107.1
unnamed: D108.2 (A), IC107.3 (D), R122.2, R137.2
unnamed: D108.1 (K), R108.1
unnamed: D109.2 (A), IC108.3 (D), R123.2, R138.2
unnamed: D109.1 (K), R109.1
unnamed: D110.2 (A), IC109.3 (D), R124.2, R139.2
unnamed: D110.1 (K), R110.1
unnamed: D111.2 (A), IC111.3 (D), R126.2, R141.2
unnamed: D111.1 (K), R111.1
unnamed: D112.2 (A), IC112.3 (D), R127.2, R142.2
unnamed: D112.1 (K), R112.1
unnamed: D113.2 (A), IC113.3 (D), R128.2, R143.2
unnamed: D113.1 (K), R113.1
unnamed: D114.2 (A), IC114.3 (D), R129.2, R144.2
unnamed: D114.1 (K), R114.1
unnamed: D115.2 (A), IC115.3 (D), R130.2, R145.2
unnamed: D115.1 (K), R115.1
unnamed: D116.1 (K), R182.1
unnamed: IC101.1 (G), R146.2
unnamed: IC102.1 (G), R147.2
unnamed: IC103.1 (G), R148.2
unnamed: IC104.1 (G), R149.2
unnamed: IC105.1 (G), R150.2
unnamed: IC106.1 (G), R151.2
unnamed: IC107.1 (G), R152.2
unnamed: IC108.1 (G), R153.2
unnamed: IC109.1 (G), R154.2
unnamed: IC110.1 (G), R155.2
unnamed: IC111.1 (G), R156.2
unnamed: IC112.1 (G), R157.2
unnamed: IC113.1 (G), R158.2
unnamed: IC114.1 (G), R159.2
unnamed: IC115.1 (G), R160.2
unnamed: C175.2, IC120.51 (VREF1)
unnamed: C176.2, IC120.50 (VREF2), IC121.3 (+IN)
unnamed: IC120.56 (WDT), R251.2
unnamed: IC122.1 (OUT), IC122.4 (-IN), R254.1
unnamed: F116.1, J103.1
unnamed: F115.1, J103.2
unnamed: F114.1, J103.3
unnamed: F113.1, J103.4
unnamed: F112.1, J103.5
unnamed: F111.1, J103.6
unnamed: F110.1, J103.7
unnamed: F109.1, J103.8
unnamed: F108.1, J103.9
unnamed: F107.1, J103.10
unnamed: F106.1, J103.11
unnamed: F105.1, J103.12
unnamed: F104.1, J103.13
unnamed: F103.1, J103.14
unnamed: F102.1, J103.15
unnamed: F101.1, J103.16
unnamed: J104.1, R183.1, R219.2
unnamed: J104.3, R187.1, R220.2
unnamed: J104.5, R191.1, R221.2
unnamed: J104.7, R195.1, R222.2
unnamed: J104.9, R199.1, R223.2
unnamed: J104.11, R203.1, R224.2
unnamed: J104.13, R207.1, R225.2
unnamed: J104.15, R211.1, R226.2
unnamed: J105.1, R184.1, R227.2
unnamed: J105.3, R188.1, R228.2
unnamed: J105.5, R192.1, R229.2
unnamed: J105.7, R196.1, R230.2
unnamed: J105.9, R200.1, R231.2
unnamed: J105.11, R204.1, R232.2
unnamed: J105.13, R208.1, R233.2
unnamed: J105.15, R212.1, R234.2
unnamed: J106.1, R185.1, R235.2
unnamed: J106.3, R189.1, R236.2
unnamed: J106.5, R193.1, R237.2
unnamed: J106.7, R197.1, R238.2
unnamed: J106.9, R201.1, R239.2
unnamed: J106.11, R205.1, R240.2
unnamed: J106.13, R209.1, R241.2
unnamed: J106.15, R213.1, R242.2
unnamed: J107.1, R186.1, R243.2
unnamed: J107.3, R190.1, R244.2
unnamed: J107.5, R194.1, R245.2
unnamed: J107.7, R198.1, R246.2
unnamed: J107.9, R202.1, R247.2
unnamed: J107.11, R206.1, R248.2
unnamed: J107.13, R210.1, R249.2
unnamed: J107.15, R214.1, R250.2
unnamed: C139.1, TR101.10 (C_RX)
unnamed: C140.2, TR101.15 (C_TX)
unnamed: J101.1, TR101.6 (RD+)
unnamed: J101.2, TR101.8 (RD-)
unnamed: J102.1, TR101.1 (TD+)
unnamed: J102.2, TR101.3 (TD-)
OUT_N1: IC120.63 (IMB), R215.2, TR101.11 (RX+)
OUT_P1: IC120.64 (IPB), R215.1, TR101.9 (RX-)
S1: IC120.37 (S1), R160.1
S2: IC120.35 (S2), R159.1
S3: IC120.33 (S3), R158.1
S4: IC120.31 (S4), R157.1
S5: IC120.29 (S5), R156.1
S7: IC120.25 (S7), R155.1
S8: IC120.23 (S8), R154.1
S9: IC120.21 (S9), R153.1
S10: IC120.19 (S10), R152.1
S11: IC120.17 (S11), R151.1
S13: IC120.13 (S13), R150.1
S14: IC120.11 (S14), R149.1
S15: IC120.9 (S15), R148.1
S16: IC120.7 (S16), R147.1
S17: IC120.5 (S17), R146.1
T0: C141.1, IC116.4 (S1), R219.1
T1: C145.1, IC116.5 (S2), R220.1
T2: C149.1, IC116.6 (S3), R221.1
T3: C153.1, IC116.7 (S4), R222.1
T4: C157.1, IC116.9 (S8), R223.1
T5: C161.1, IC116.10 (S7), R224.1
T6: C165.1, IC116.11 (S6), R225.1
T7: C169.1, IC116.12 (S5), R226.1
T8: C142.1, IC117.4 (S1), R227.1
T9: C146.1, IC117.5 (S2), R228.1
T10: C150.1, IC117.6 (S3), R229.1
T11: C154.1, IC117.7 (S4), R230.1
T12: C158.1, IC117.9 (S8), R231.1
T13: C162.1, IC117.10 (S7), R232.1
T14: C166.1, IC117.11 (S6), R233.1
T15: C170.1, IC117.12 (S5), R234.1
T16: C143.1, IC118.4 (S1), R235.1
T17: C147.1, IC118.5 (S2), R236.1
T18: C151.1, IC118.6 (S3), R237.1
T19: C155.1, IC118.7 (S4), R238.1
T20: C159.1, IC118.9 (S8), R239.1
T21: C163.1, IC118.10 (S7), R240.1
T22: C167.1, IC118.11 (S6), R241.1
T23: C171.1, IC118.12 (S5), R242.1
T24: C144.1, IC119.4 (S1), R243.1
T25: C148.1, IC119.5 (S2), R244.1
T26: C152.1, IC119.6 (S3), R245.1
T27: C156.1, IC119.7 (S4), R246.1
T28: C160.1, IC119.9 (S8), R247.1
T29: C164.1, IC119.10 (S7), R248.1
T30: C168.1, IC119.11 (S6), R249.1
T31: C172.1, IC119.12 (S5), R250.1
V+: C117.1, IC120.1 (V+), R162.2
VREF2: C133.1, C134.1, C135.1, C136.1, C179.2, IC121.1 (OUT), IC121.4 (-IN), R183.2, R184.2, R185.2, R186.2, R187.2, R188.2, R189.2, R190.2, R191.2, R192.2, R193.2, R194.2, R195.2, R196.2, R197.2, R198.2, R199.2, R200.2, R201.2, R202.2, R203.2, R204.2, R205.2, R206.2, R207.2, R208.2, R209.2, R210.2, R211.2, R212.2, R213.2, R214.2
VREG: C137.2, C138.2, C173.2, C174.2, C177.2, C178.1, D116.2 (A), IC116.2 (~RESET), IC116.13 (VDD), IC117.2 (~RESET), IC117.13 (VDD), IC117.16 (A0), IC118.2 (~RESET), IC118.13 (VDD), IC118.15 (A1), IC119.2 (~RESET), IC119.13 (VDD), IC119.15 (A1), IC119.16 (A0), IC120.48 (VREG), IC120.52 (DTEN), IC120.55 (ISOMD), IC121.5 (V+), IC122.5 (V+), R217.2, R218.1, R251.1; also elsewhere on the board

Notes on the sheet:
100V
ISOSPI_IN+
不知道能不能拔掉??
ISOSPI_OUT-
ISOSPI_OUT+
ISOSPI_IN-

Parts:
C201: 2.2u; C_2220_5650Metric
C202: 100p; C_0603_1608Metric
C203: 0.1u; C_0603_1608Metric
C204: 4.7p; C_0603_1608Metric
C205: 2.2u; C_0603_1608Metric
C206: 22u; C_1206_3216Metric
IC201: LT8631IFE#PBF; SOP65P640X120-21N; Mouser Part Number 584-LT8631IFE#PBF
L201: 22u/2A; L_Bourns-SRN8040_8x8.15mm
R255: 25.5k; R_0603_1608Metric
R256: 1M/1%; R_0603_1608Metric
R257: 191k/1%; R_0603_1608Metric

Connections:
/Power/VIN: C201.1, IC201.1 (VIN); also elsewhere on the board
Cell0-: C201.2, C202.2, C205.2, C206.2, IC201.7 (SYNC/MODE), IC201.21 (GND), R255.2, R257.2; also elsewhere on the board
DRIVE: IC201.3 (EN/UV); also elsewhere on the board
unnamed: C203.1, IC201.18 (BST)
unnamed: C204.1, IC201.11 (FB), R256.2, R257.1
unnamed: IC201.14 (IND), L201.1
unnamed: C205.1, IC201.16 (INTVCC)
unnamed: IC201.8 (RT), R255.1
unnamed: C203.2, IC201.20 (SW), L201.2
unnamed: C202.1, IC201.10 (TR/SS)
VREG: C204.2, C206.1, IC201.12 (VOUT), R256.1; also elsewhere on the board

Board: 4 copper layers, 200.0 x 50.0 mm, 326 parts (143 on the bottom side), 208 nets.

## KiCad design EP5/Powertrain/BatteryBox/Connector_Board/Connector_Board.kicad_pcb

Board: 2 copper layers, 45.0 x 115.0 mm, 18 parts (10 on the bottom side), 14 nets.

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_DIN965_Pad_TopBottom
J1: Conn_01x02; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J2: HV_Box; M8 5-6P w Ground
J3: TSMS; M12 2-5P w Ground
J4: RS422; M8 5-6P w Ground
J5: IMD; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J6: BMS_PWR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: PC_SC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: PC_GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J9: PC_DCDC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: PC_DC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J11: BMS_ERR; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J12: RS422; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J13: CAN; M8 3P w Ground
J14: CAN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical

Connections:
+5V: J4.1, J12.6
BMS_ERROR: J2.1, J11.2
CANH: J13.3, J14.1
CANL: J13.1, J14.2
DC: J2.2, J10.2
DCDC: J2.3, J9.2
Earth_Protective: H1.1, H2.1, H3.1, H4.1, J1.1, J2.5, J2.7, J3.6, J4.6, J4.7, J5.1, J5.3, J6.1, J8.1, J8.2, J9.1, J10.1, J11.1, J12.1, J13.2, J13.4
IMD_ERROR: J2.4, J5.2
unnamed: J4.5, J12.2
unnamed: J4.4, J12.3
unnamed: J4.3, J12.4
unnamed: J4.2, J12.5
TSMS: J3.1, J3.3, J7.1, J7.2
VCC: J1.2, J5.4, J6.2

## KiCad design EP5/Powertrain/BatteryBox/Indicator/Indicator.kicad_pcb

Board: 2 copper layers, 50.0 x 50.0 mm, 13 parts (0 on the bottom side), 6 nets.

Parts:
D1: 1N53xxB; D_DO-201_P15.24mm_Horizontal
F1: 500V/0.5A; 65600001009
H1, H2, H3, H4: MountingHole; MountingHole_4.3mm_M4_DIN965
H**: WAT247101E
J1: HV+; DF33C2P33DSA24
J2: HV-; DF33C2P33DSA24
J3: LED+; DF33C2P33DSA24
J4: LED-; DF33C2P33DSA24
Q1: IXTH6N100D2; TO-247-3_Vertical
RV1: 1k; Potentiometer_Bourns_3386C_Horizontal

Connections:
unnamed: D1.2 (A), Q1.2 (D)
unnamed: D1.1 (K), F1.2 (-)
unnamed: F1.1 (+), J1.1, J1.2
unnamed: J2.1, J2.2, J4.1, J4.2
unnamed: J3.1, J3.2, Q1.1 (G), RV1.2, RV1.3
unnamed: Q1.3 (S), RV1.1

## KiCad design EP5/Powertrain/BatteryBox/PreCharge/PreCharge.kicad_pcb

Parts:
C1, C5, C6: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 100u; CP_Elec_10x10
C3: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 10n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D4, D5: 1N4001; D_SOD-123F
D2: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2: MountingHole; MountingHole_4.3mm_M4_DIN965
H3, H4: MountingHole_Pad; MountingHole_4.3mm_M4_DIN965_Pad_TopBottom
J4: SCIN; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J5: GND; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: DCDC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7: DisCharge; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J8: AIR+; DF33C2P33DSA24
J9: AIR-; DF33C2P33DSA24
K1: DBT72410; Manufacturer_Part_Number DBT72410
Q1, Q2, Q3: 2N7002; SOT-23
R4, R5: 3.9k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RL1, RL2: G2RL-24-DC24; Relay_DPDT_Omron_G2RL
RV1: R_Potentiometer; Potentiometer_Bourns_3299W_Vertical
U1: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U2: L7805; TO-252-3_TabPin2

Connections:
+5V: C5.1, R7.1, RV1.1, U2.3 (OUT)
AIR+: D5.1 (K), J8.1, RL1.4
DCDC_CRTL: J6.1, RL1.5
Discharge: C1.1, R7.2, RL2.2, U1.3 (+)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D4.2 (A), D5.2 (A), H3.1, H4.1, J5.1, J5.2, J6.2, J7.2, J8.2, J9.2, K1.3 (COIL-), Q1.2 (S), Q2.2 (S), Q3.2 (S), RL2.3, RL2.8, RV1.3, U1.4 (V-), U2.2 (GND)
unnamed: D1.2 (A), Q1.3 (D), RL1.8
unnamed: D2.2 (A), R4.2
unnamed: D2.1 (K), Q3.3 (D)
unnamed: D3.2 (A), R5.2
unnamed: D3.1 (K), Q2.3 (D)
unnamed: Q1.1 (G), Q3.1 (G), R6.2, U1.1
unnamed: C4.1, RV1.2, U1.2 (-)
SC_IN: C2.1, C3.1, C6.1, D1.1 (K), D4.1 (K), J4.1, J4.2, J7.1, J9.1, K1.4 (COIL+), Q2.1 (G), R4.1, R5.1, R6.1, RL1.1, RL1.3, RL1.6, RL2.1, U1.8 (V+), U2.1 (IN)
